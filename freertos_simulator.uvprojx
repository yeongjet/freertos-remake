# Keil uVision project freertos_simulator.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: freertos_simulator
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\freertos\FreeRTOSv10.2.1\FreeRTOS\Source\include;..\freertos\FreeRTOSv10.2.1\FreeRTOS\Source\portable\Keil
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group source
    ./source/: main.c portmacro.h task.c task.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.1.0
